# Keil uVision project NorFlash.uvprojx, settings and files
target Cortex-M (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H7R7L8HxH STMicroelectronics
  pack: Keil.STM32H7RSxx_DFP.1.0.0
  cpu: IRAM(0x00000000,0x00010000) IRAM2(0x20000000,0x00010000) IROM(0x08000000,0x00010000) XRAM(0x24000000,0x00072000) XRAM2(0x30000000,0x00008000) XRAM3(0x38800000,0x00001000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: ATK_NorFlash_W25Q128
  AfterMake: cmd.exe /C copy "Objects\%L" ".\@L.FLM"
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: FLASH_MEM,USE_HAL_DRIVER, STM32H7RSxx
  c include: .\Drivers\STM32H7RSxx_HAL_Driver\Inc;.\BSP;.\Drivers\CMSIS\Device\ST\STM32H7RSxx\Include;.\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT6: RAM 0x24000000 size 0x72000
  memory RVCT7: RAM 0x30000000 size 0x8000
  memory RVCT8: RAM 0x38800000 size 0x1000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Documentation
    ./: Abstract.txt
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group HAL_Driver
    ./Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_xspi.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_rcc_ex.c
    ./Drivers/CMSIS/Device/ST/STM32H7RSxx/Source/Templates/: system_stm32h7rsxx.c
  group BSP
    ./BSP/: norflash_w25q128.c bsp.c
